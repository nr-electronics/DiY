# IAR project st77xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; gpio; delay; timers; display; display\fonts; fatfs; spim; st77xx; STM32F10x_StdPeriph_Driver\inc; STM32F10x_StdPeriph_Driver\src; CMSIS; CMSIS\Core; CMSIS\Core\CM3\startup\iar; CMSIS\Core\CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: st77xx.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: button.c button.h main.c main.h readme.txt test.c test.h test240x240.c test240x240.h test80x160.c test80x160.h types.h
  group CMSIS
    CMSIS/Core/CM3/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c
    CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_md.s
  group delay
    delay/: delay.c delay.h
  group display
    display/: disp_common.c disp_common.h dispcolor.c dispcolor.h
  group display/fonts
    display/fonts/: f16f.c f16f.h f24f.c f24f.h f32f.c f32f.h f6x8m.c f6x8m.h font.c font.h
  group fatfs
    fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c integer.h
  group gpio
    gpio/: gpio.c gpio.h
  group spim
    spim/: spim.c spim.h
  group st77xx
    st77xx/: st7735.c st7735.h st7789.c st7789.h st77xx.c st77xx.h
  group STM32F10x_StdPeriph_Driver/inc
    STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STM32F10x_StdPeriph_Driver/src
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group timers
    timers/: timers.h tmr2.c tmr2.h
